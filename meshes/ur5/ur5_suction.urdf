Commit message: realsense

File: meshes/ur5/ur5_suction.urdf (robot description, URDF)
Before this commit: robot ur5, 22 links, 21 joints
Links:
- link cup_bar: mass 0.01 -> 0.00; geometry visual cylinder length=0.05 radius=0.01
